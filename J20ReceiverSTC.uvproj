# Keil uVision project J20ReceiverSTC.uvproj, settings and files
target J20ReceiverSTC (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: J20ReceiverSTC +hex
  c flags: Optimize=9 SizeSpeed=1
  group user
    ./: STARTUP.A51 user.c
